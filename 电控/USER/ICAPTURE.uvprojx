# Keil uVision project ICAPTURE.uvprojx, settings and files
target ICAPTURE (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: ICAPTURE +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\TIMER;..\FWLIB\inc;..\HARDWARE\MOTOR;..\HARDWARE\ADC;..\HARDWARE\OLED;..\HARDWARE\TASK;..\HARDWARE\BLUETOOTH;..\HARDWARE\ENCODER;..\HARDWARE\PS2;..\HARDWARE\MOTOR42;..\HARDWARE\KEY;..\HARDWARE\USART3;..\HARDWARE\LED;..\HARDWARE\ANGLE;..\HARDWARE\SERVO
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/TASK/: Task.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MOTOR/: Motor.c
    ../HARDWARE/ENCODER/: Encoder.c
    ../HARDWARE/MOTOR42/: Motor42.c
    ../HARDWARE/ADC/: Adc.c
    ../HARDWARE/BLUETOOTH/: Bluebooth.c
    ../HARDWARE/PS2/: PS2.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/USART3/: Usart3.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ANGLE/: Angle.c
    ../HARDWARE/SERVO/: Servo.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c
  group README
    ../: readme.txt
